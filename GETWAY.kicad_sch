File: GETWAY.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Add files via upload
Other:
- note removed: "Kiểu OSC?"
